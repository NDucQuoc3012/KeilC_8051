# Keil uVision project LCD_I2C.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT80C51RD2 Microchip
  cpu: IRAM(0x00 - 0xFF) XRAM(0x00 - 0x3FF) CLOCK(40000000) MODP2
  output: LCD_I2C +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\Bai_10_LCD_I2C;..\Bai_10_LCD_I2C
  group Source Group 1
    ./: STARTUP.A51 LCD_I2C.c Thu_Vien_LCD_I2C.c
